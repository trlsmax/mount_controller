# Keil uVision project eqmax.uvprojx, settings and files
target eqmax (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: eqmax +hex
  AfterMake: C:\Keil\ARM\ARMCC\Bin\fromelf.exe --bin -o ../eqmax.bin ./Objects/eqmax.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,MOUNT_ENABLE,FOCUSER_ENABLE,USE_IO,FW_TYPE=0x0003
  c include: ..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6400
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../: hw_config.c main.c stm32_it.c synta.c system_stm32f10x.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group periph_lib
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group usb_lib
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group startup
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
target eqmax_debug (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: eqmax +hex
  AfterMake: as above
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, DEBUG,MOUNT_ENABLE,FOCUSER_ENABLE,USE_IO,FW_TYPE=0x0003
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6400
  memory RVCT9: RAM 0x20000000 size 0x5000
target mount (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: mount +hex
  AfterMake: C:\Keil\ARM\ARMCC\Bin\fromelf.exe --bin -o ../mount.bin ./Objects/mount.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,MOUNT_ENABLE,FW_TYPE=0x0001
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6400
  memory RVCT9: RAM 0x20000000 size 0x5000
target mount_debug (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: as above
  output: mount +hex
  AfterMake: as above
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, DEBUG,MOUNT_ENABLE,FW_TYPE=0x0001
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6400
  memory RVCT9: RAM 0x20000000 size 0x5000
target focuser (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: as above
  output: focuser +hex
  AfterMake: C:\keil\ARM\ARMCC\Bin\fromelf.exe --bin -o ../focuser.bin ./Objects/focuser.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, FOCUSER_ENABLE, USE_IO,FW_TYPE=0x0002
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6400
  memory RVCT9: RAM 0x20000000 size 0x5000
target focuser_debug (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: as above
  output: focuser +hex
  AfterMake: C:\Keil\ARM\ARMCC\Bin\fromelf.exe --bin -o ../focuser.bin ./Objects/focuser.axf
  c flags: OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, DEBUG, FOCUSER_ENABLE, USE_IO,FW_TYPE=0x0002
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6400
  memory RVCT9: RAM 0x20000000 size 0x5000
